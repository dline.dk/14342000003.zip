Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-07T09:52:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 07 09:52:17 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{75D53232-420D-4C99-86D1-889D34DDC3BD}\ifc * Database version: 5507 * Database creation date: Tue Nov 07 09:52:17 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 07 09:52:17 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 07 09:52:17 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDoor: dline_Hardware_PanicExitDomes_52, 14342000003b:dline_Hardware_PanicExitDomes_52:194053
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_PanicExitDomes_52; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 71 00; MasterFormat2014Description: Door hardware; NBSCertification: n/a; NBSDescription: Emergency break glass units; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 90-75-05/480; NBSTypeID: n/a; OmniclassCode: 22-08 71 00; OmniclassDescription: Door Hardware; ProductFamily: Hardware; ProductGroup: Break glass domes; ProductInformation: http://dline.com/product/knud-holscher-collection-panic-exit-device-break-glass-dome/?attribute_pa_material=pmma&attribute_pa_item=o52-only-hight-28-mm#; ProductionCountry: Lithuania; ProductSKU: 14342000003; Revision: n/a; Uniclass2015Code: Pr_75_75_27_27; Uniclass2015Title: Emergency door release break glass units; Uniclass2015Version: Products v1.5; UNSPSCCode: 31162801; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: Emergency exit, break glass dome; Manufacturer: info@dline.com; Type Mark: 22; Type Name: dline_Hardware_PanicExitDomes_52
Type - Materials and Finishes - MainMaterial: AISI 316; SupplementaryMaterial1: Plastic clear
Type - Other - Category: Doors; AccessibilityPerformance: n/a; AssetType: fixed; CodePerformance: n/a; Color: n/a; Constituents: Panic exit, break glass dome; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14342000003b; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 326 stainless steel; ModelNumber: n/a; ModelReference: 90-75-05/480; Name: PanicExitDomes_52; ReplacementCost: n/a; Shape: n/a; Size: 28 x 52 x 52 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 28 mm; OverallWidth: 52 mm
Pset_DoorCommon - Reference: dline_Hardware_PanicExitDomes_52; IsExternal: no
Pset_ManufacturerTypeInformation - ModelReference: 90-75-05/480; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Dimensions - Area: 0.00586002 m2; Volume: 0.0000499315 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: n/a; Family: 14342000003b: dline_Hardware_PanicExitDomes_52; Family and Type: 14342000003b: dline_Hardware_PanicExitDomes_52; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14342000003b: dline_Hardware_PanicExitDomes_52; Type Id: 14342000003b: dline_Hardware_PanicExitDomes_52; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
